# Keil uVision project Robot.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Robot +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: action.c Robot.c timer.c uart.c delay.c pwm.c XFS5152V2.c adc.c IIC.c MPU6050.c oled.c
